# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXN947VDF_cm33_core0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\Libraries\MCXN947\MCXN947\drivers\romapi\nboot; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\finsh; ..\Libraries\MCXN947\MCXN947\drivers\romapi\runbootloader; ..\Libraries\MCXN947\MCXN947; ..\Libraries\MCXN947\MCXN947\drivers; applications; ..\..\..\..\..\components\drivers\smp; ..\Libraries\MCXN947\MCXN947\drivers\romapi\flash; ..\Libraries\MCXN947\MCXN947\drivers\romapi\mem_interface; ..\Libraries\drivers\config; ..\..\..\..\..\components\utilities\ulog; .; ..\..\..\..\..\libcpu\arm\cortex-m33; ..\..\..\..\..\libcpu\arm\common; board; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\libc\posix\ipc; ..\Libraries\drivers; ..\..\..\..\..\components\drivers\include; board\MCUX_Config\board; ..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\include; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board\linker_scripts\MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXN947VDF_cm33_core0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_port.c usb_phy.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_gdet.c fsl_pint.c fsl_lpuart.c fsl_reset.c fsl_spc.c fsl_tsi_v6.c fsl_lpi2c.c fsl_puf_v3.c fsl_qdc.c fsl_sinc.c fsl_common.c fsl_syspm.c fsl_edma.c fsl_trdc.c fsl_intm.c fsl_flexio.c fsl_flexio_mculcd_edma.c fsl_flexio_spi_edma.c fsl_lpcmp.c fsl_lpspi.c fsl_flexspi.c fsl_dac14.c fsl_flexio_mculcd_smartdma.c fsl_sai.c fsl_flexio_uart.c fsl_smartdma.c fsl_dac.c fsl_irtc.c fsl_flexcan_edma.c fsl_powerquad_basic.c fsl_lptmr.c fsl_pwm.c fsl_utick.c fsl_wwdt.c fsl_lpspi_edma.c fsl_flexio_uart_edma.c fsl_ctimer.c fsl_sctimer.c fsl_mrt.c fsl_i3c.c fsl_plu.c fsl_flexio_mculcd.c fsl_powerquad_matrix.c fsl_vref.c fsl_flexio_spi.c fsl_edma_soc.c fsl_opamp.c fsl_smartcard_emvsim.c fsl_ostimer.c fsl_flexspi_edma.c fsl_flexcan.c fsl_sai_edma.c fsl_eim.c fsl_wuu.c fsl_lpadc.c fsl_itrc.c fsl_i3c_edma.c fsl_powerquad_data.c fsl_flexio_i2c_master.c fsl_gpio.c fsl_powerquad_math.c fsl_common_arm.c fsl_lpi2c_edma.c fsl_ewm.c fsl_cache_lpcac.c fsl_cdog.c fsl_cache.c fsl_pdm.c fsl_power.c fsl_powerquad_filter.c fsl_smartdma_mcxn.c fsl_pdm_edma.c fsl_erm.c fsl_usdhc.c fsl_evtg.c fsl_smartdma_rt500.c fsl_enet.c fsl_tdet.c fsl_smartcard_phy_emvsim.c fsl_inputmux.c fsl_crc.c fsl_powerquad_transform.c fsl_vbat.c fsl_lpuart_edma.c fsl_sema42.c fsl_cmc.c fsl_lpflexcomm.c fsl_clock.c fsl_freqme.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    ../Libraries/MCXN947/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
