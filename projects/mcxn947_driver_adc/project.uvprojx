# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6160000::V6.16::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, DEBUG, RT_USING_LIBC, __RTTHREAD__, CPU_MCXN947VDF_cm33_core0, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\runbootloader;board;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\libcpu\arm\cortex-m33;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\drivers;rt-thread\components\drivers\include;packages\nxp-mcx-cmsis-latest\Core\Include;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\mem_interface;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;packages\nxp-mcx-series-latest\MCXN947;.;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\flash;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\stdio;rt-thread\libcpu\arm\common;packages\nxp-mcx-series-latest\MCXN947\drivers\romapi\nboot;libraries\drivers\config;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;board\MCUX_Config\board;rt-thread\components\libc\compilers\common\include;applications;packages\nxp-mcx-series-latest\MCXN947\drivers
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: main.c adc_test.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c dac.c pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_port.c usb_phy.c
    libraries/drivers/: drv_adc.c drv_dac.c drv_hwtimer.c drv_i2c.c drv_pin.c drv_pwm.c drv_rtc.c drv_sdio.c drv_spi.c drv_uart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh_parse.c msh_file.c msh.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    packages/nxp-mcx-series-latest/MCXN947/drivers/: fsl_cache.c fsl_cache_lpcac.c fsl_cdog.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_dac.c fsl_dac14.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_enet.c fsl_erm.c fsl_evtg.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_smartdma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexspi.c fsl_flexspi_edma.c fsl_freqme.c fsl_gdet.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_intm.c fsl_irtc.c fsl_itrc.c fsl_lpadc.c fsl_lpcmp.c fsl_lpflexcomm.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_mrt.c fsl_opamp.c fsl_ostimer.c fsl_pdm.c fsl_pdm_edma.c fsl_pint.c fsl_plu.c fsl_power.c fsl_powerquad_basic.c fsl_powerquad_data.c fsl_powerquad_filter.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_transform.c fsl_puf_v3.c fsl_pwm.c fsl_qdc.c fsl_reset.c fsl_sai.c fsl_sai_edma.c fsl_sctimer.c fsl_sema42.c fsl_sinc.c fsl_smartcard_emvsim.c fsl_smartcard_phy_emvsim.c fsl_smartdma.c fsl_smartdma_mcxn.c fsl_smartdma_rt500.c fsl_spc.c fsl_syspm.c fsl_tdet.c fsl_trdc.c fsl_tsi_v6.c fsl_usdhc.c fsl_utick.c fsl_vbat.c fsl_vref.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    packages/nxp-mcx-series-latest/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    packages/nxp-mcx-series-latest/MCXN947/: system_MCXN947_cm33_core0.c
